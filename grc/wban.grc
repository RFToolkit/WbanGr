options:
  parameters:
    author: zero
    generate_options: qt_gui
    id: wban
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /opt/gr-wban/d.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/gr-wban/rx
    repeat: 'True'
    type: complex
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    packet_len_key: '"length"'
    payload_mod: '"BPSK"'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/4
    win: window.WIN_HAMMING
  states: {}

connections:
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [digital_ofdm_rx_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', digital_ofdm_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
