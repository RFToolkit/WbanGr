options:
  parameters:
    author: zero
    generate_options: qt_gui
    id: wban
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0
    label: Channel Number
    labels: '[]'
    num_opts: '0'
    options: '[11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26]'
    type: int
    value: '11'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2405000000 + 5000000*(channel - 11)
  states: {}
- name: freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0
    label: Frequency (GHz)
    type: real
    value: freq / 1000000000.0
  states: {}
- name: page_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: Channel Page
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {state: disabled}
- name: ieee802_15_4_frame_buffer_cc_0
  id: ieee802_15_4_frame_buffer_cc
  parameters:
    nsym_frame: '1'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [ieee802_15_4_frame_buffer_cc_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', qtgui_time_sink_x_0_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [ieee802_15_4_oqpsk_phy_0, rxout, qtgui_time_sink_x_0, in]
- [osmosdr_source_0, '0', ieee802_15_4_frame_buffer_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
