options:
  parameters:
    author: Dimitrios-Georgios Akestoridis
    description: A simplified version of Bastian Bloessl's GRC flow graph for an IEEE 802.15.4 transceiver.
    generate_options: qt_gui
    id: ieee802154_transceiver
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 Transceiver
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 98,0,1,1
    label: BB
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: bt
  id: variable_qtgui_range
  parameters:
    gui_hint: 60,0,1,1
    label: bt
    start: '0'
    step: '1'
    stop: '50'
    value: '15'
  states: {}
- name: channel
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 99,0,1,1
    label: Channel Number
    labels: '[]'
    num_opts: '0'
    options: '[11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26]'
    type: int
    value: '20'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2405000000 + 5000000*(channel - 11)
  states: {}
- name: freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0
    label: Frequency (GHz)
    type: real
    value: freq / 1000000000.0
  states: {}
- name: freqd
  id: variable_qtgui_range
  parameters:
    gui_hint: 40,0,1,2
    label: freqd
    start: '926'
    step: '1'
    stop: '6000'
    value: '926'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 97,0,1,1
    label: if_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: page_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: Channel Page
    type: int
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 96,0,1,1
    start: '0'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: symb
  id: variable_qtgui_range
  parameters:
    gui_hint: 90,0,1,1
    label: symb
    start: '2'
    step: '1'
    stop: '50'
    value: '3'
  states: {}
- name: symb0
  id: variable_qtgui_range
  parameters:
    gui_hint: 80,0,1,1
    label: symb0
    start: '2'
    step: '1'
    stop: '50'
    value: '8'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-20'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-38'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /opt/gr-wban/yyy.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /opt/gr-wban/c5.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /opt/gr-wban/c2.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/in.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /opt/gr-wban/wpan.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /opt/gr-wban/yyy.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /opt/gr-wban/wpan.wav
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/gr-wban/wpan.wav
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 172.17.0.2
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100'
    type: float
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '200'
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_crc16_async_bb_0_0
  id: digital_crc16_async_bb
  parameters:
    check: 'False'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: symb0
    resamp_type: digital.IR_MMSE_8TAP
    sps: symb
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: ff
  states: {}
- name: dtv_dvbt2_cellinterleaver_cc_0
  id: dtv_dvbt2_cellinterleaver_cc
  parameters:
    constellation: MOD_QPSK
    fecblocks: '168'
    framesize: FECFRAME_NORMAL
    tiblocks: '3'
  states: {state: disabled}
- name: dtv_dvbt_map_0
  id: dtv_dvbt_map
  parameters:
    constellation: qpsk
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: foo_wireshark_connector_0_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {state: disabled}
- name: ieee802_15_4_frame_buffer_cc_0
  id: ieee802_15_4_frame_buffer_cc
  parameters:
    nsym_frame: '1'
  states: {state: disabled}
- name: ieee802_15_4_frame_buffer_cc_0_0
  id: ieee802_15_4_frame_buffer_cc
  parameters:
    nsym_frame: '1'
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '245'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '25000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: LNAH
    args: rtl
    bb_gain0: bb_gain
    dc_offset_mode0: '2'
    freq0: 210*1e6
    gain0: rx_gain
    gain_mode0: 'True'
    if_gain0: if_gain
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: rtl
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq+5000000
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_1_1
  id: qtgui_const_sink_x
  parameters:
    color1: '"Dark Blue"'
    gui_hint: 1,0,1,4
    label1: Rx raw
    marker1: '9'
    name: '"Rx"'
    size: '1024'
    style1: '1'
    tr_level: '0.4'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    xmax: '0.4'
    xmin: '-0.4'
    ymax: '0.4'
    ymin: '-0.4'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 8,0,1,4
    label1: Raw DC Blocked R
    label2: Raw DC Blocked I
    name: '"Rx"'
    size: '1024'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1_2_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 5,0,1,4
    label1: Raw DC Blocked R
    name: '"Rx"'
    size: '1024'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/2
    fc: freq
    fftsize: '1024'
    gui_hint: 7,0,1,4
    label1: Raw
    name: '"raw"'
    showports: 'True'
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.000150'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '640'
    fps: '2000'
    height: '480'
    type: byte
    width: '640'
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_sub_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_file_sink_0_0_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ieee802_15_4_frame_buffer_cc_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', ieee802_15_4_frame_buffer_cc_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_sub_xx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_sub_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, foo_wireshark_connector_0, in]
- [blocks_tagged_stream_to_pdu_0_0, pdus, digital_crc16_async_bb_0_0, in]
- [blocks_tagged_stream_to_pdu_0_0, pdus, foo_wireshark_connector_0_0, in]
- [blocks_tagged_stream_to_pdu_1, pdus, blocks_socket_pdu_0, pdus]
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0_0, '0', low_pass_filter_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_complex_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', blocks_float_to_complex_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_crc16_async_bb_0_0, out, foo_wireshark_connector_0_0, in]
- [digital_symbol_sync_xx_0, '0', ieee802_15_4_packet_sink_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0_1, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0_1_0, '0']
- [foo_wireshark_connector_0, '0', blocks_tagged_stream_to_pdu_1, '0']
- [foo_wireshark_connector_0, '0', qtgui_number_sink_0, '0']
- [foo_wireshark_connector_0_0, '0', blocks_file_sink_0_0_0, '0']
- [foo_wireshark_connector_0_0, '0', blocks_file_sink_0_1, '0']
- [ieee802_15_4_frame_buffer_cc_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [ieee802_15_4_frame_buffer_cc_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [ieee802_15_4_packet_sink_0, out, foo_wireshark_connector_0, in]
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_const_sink_x_1_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1_2, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [osmosdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_1, '0']
- [osmosdr_source_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [single_pole_iir_filter_xx_0, '0', qtgui_time_sink_x_1_2_0_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_sub_xx_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
