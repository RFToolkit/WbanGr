options:
  parameters:
    author: Dimitrios-Georgios Akestoridis
    description: A simplified version of Bastian Bloessl's GRC flow graph for an IEEE 802.15.4 transceiver.
    generate_options: qt_gui
    id: ieee802154_transceiver
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 Transceiver
  states: {}

blocks:
- name: channel
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0
    label: Channel Number
    labels: '[]'
    num_opts: '0'
    options: '[11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26]'
    type: int
    value: '20'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2405000000 + 5000000*(channel - 11)
  states: {}
- name: freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0
    label: Frequency (GHz)
    type: real
    value: freq / 1000000000.0
  states: {}
- name: page_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: Channel Page
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ieee802154.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /opt/gr-wban/tx.out
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_socket_pdu_0, pdus, ieee802_15_4_oqpsk_phy_0, txin]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_file_sink_1, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [osmosdr_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
