options:
  parameters:
    author: Dimitrios-Georgios Akestoridis
    description: A simplified version of Bastian Bloessl's GRC flow graph for an IEEE 802.15.4 transceiver.
    generate_options: qt_gui
    id: ieee802154_transceiver
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 Transceiver
  states: {}

blocks:
- name: channel
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0
    label: Channel Number
    labels: '[]'
    num_opts: '0'
    options: '[11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26]'
    type: int
    value: '12'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2405000000 + 5000000*(channel - 11)
  states: {}
- name: freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0
    label: Frequency (GHz)
    type: real
    value: freq / 1000000000.0
  states: {}
- name: page_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: Channel Page
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /opt/gr-wban/yyy.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /opt/gr-wban/p.bin
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '32'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: complex
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/4
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, foo_wireshark_connector_0, in]
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_file_sink_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
