options:
  parameters:
    author: root
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 98,0,1,1
    label: BB
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: bt
  id: variable_qtgui_range
  parameters:
    gui_hint: 60,0,1,1
    label: bt
    start: '0'
    step: '1'
    stop: '50'
    value: '15'
  states: {}
- name: channel
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 99,0,1,1
    label: Channel Number
    labels: '[]'
    num_opts: '0'
    options: '[11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49]'
    type: int
    value: '49'
  states: {}
- name: decode
  id: variable_dummy_decoder_def
  parameters:
    framebits: '2048'
    ndim: '0'
  states: {}
- name: encode
  id: variable_dummy_encoder_def
  parameters:
    framebits: '2048'
    ndim: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2400500000 + 1000000*(channel - 11)
  states: {}
- name: freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0
    label: Frequency (GHz)
    type: real
    value: freq / 1000000000.0
  states: {}
- name: freqd
  id: variable_qtgui_range
  parameters:
    gui_hint: 40,0,1,2
    label: freqd
    start: '926'
    step: '1'
    stop: '6000'
    value: '926'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 97,0,1,1
    label: if_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: page_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: Channel Page
    type: int
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 96,0,1,1
    start: '0'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: symb
  id: variable_qtgui_range
  parameters:
    gui_hint: 90,0,1,1
    label: symb
    start: '2'
    step: '1'
    stop: '50'
    value: '16'
  states: {}
- name: symb0
  id: variable_qtgui_range
  parameters:
    gui_hint: 80,0,1,1
    label: symb0
    start: '2'
    step: '1'
    stop: '50'
    value: '4'
  states: {}
- name: variable0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_0
    modulus: '2'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0_0_0_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0_0_0_2
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0_0_0_3
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-15'
  states: {}
- name: ber_test
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"BER"'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /opt/gr-wban/wpan.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: /opt/gr-wban/stdOut.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /opt/gr-wban/wpan.wav
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/gr-wban/wpan.wav
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0_0_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0_0_0_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0_0_0_3
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*4
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_0_0_0_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_0_0_0_2
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_0_0_0_3
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.00225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable0
    num_taps: '64'
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: symb0
    resamp_type: digital.IR_MMSE_8TAP
    sps: symb
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: ff
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: symb0
    resamp_type: digital.IR_MMSE_8TAP
    sps: symb
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: ff
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: decode
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: encode
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: foo_wireshark_connector_0_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '200000'
    decim: '10'
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,samp_rate/(2*10), 200000)'
    type: ccf
  states: {}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {}
- name: ieee802_15_4_packet_sink_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_0_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_0_0_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_0_0_0_1
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_0_0_0_2
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_0_0_0_3
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_1
  id: ieee802_15_4_packet_sink
  parameters:
    th: bt
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/4
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 4000000/2
    decim: freq//16000000
    gain: '1'
    samp_rate: '4000000'
    type: fir_filter_ccf
    width: 4000000/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 4000000/2
    decim: freq//27000000
    gain: '1'
    samp_rate: '4000000'
    type: fir_filter_ccf
    width: 4000000/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 300000/2
    decim: freq//402000000
    gain: '1'
    samp_rate: '300000'
    type: fir_filter_ccf
    width: 300000/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 300000/2
    decim: freq//420000000
    gain: '1'
    samp_rate: '300000'
    type: fir_filter_ccf
    width: 300000/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 400000/2
    decim: freq//863000000
    gain: '1'
    samp_rate: '400000'
    type: fir_filter_ccf
    width: 400000/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 500000/2
    decim: freq//902000000
    gain: '1'
    samp_rate: '500000'
    type: fir_filter_ccf
    width: 500000/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 400000/2
    decim: freq//956000000
    gain: '1'
    samp_rate: '400000'
    type: fir_filter_ccf
    width: 400000/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: freq//2360000000
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: LNAH
    args: hackrf
    bb_gain0: bb_gain+2
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rx_gain+10
    gain_mode0: 'True'
    if_gain0: if_gain+5
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: rtl
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq+5000000
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_1_1
  id: qtgui_const_sink_x
  parameters:
    color1: '"Dark Blue"'
    gui_hint: 1,0,1,4
    label1: Rx raw
    marker1: '9'
    name: '"Rx"'
    size: '1024'
    style1: '1'
    tr_level: '0.4'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    xmax: '0.4'
    xmin: '-0.4'
    ymax: '0.4'
    ymin: '-0.4'
  states: {state: disabled}
- name: qtgui_const_sink_x_1_1_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"Dark Blue"'
    gui_hint: 3,0,1,4
    label1: Rx raw
    marker1: '9'
    name: '"Rx2"'
    size: '1024'
    style1: '1'
    tr_level: '0.4'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    xmax: '0.4'
    xmin: '-0.4'
    ymax: '0.4'
    ymin: '-0.4'
  states: {}
- name: qtgui_const_sink_x_1_1_0_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"Dark Blue"'
    gui_hint: 2,1,1,4
    label1: Rx raw
    marker1: '9'
    name: '"sink"'
    size: '1024'
    style1: '1'
    tr_level: '0.4'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    xmax: '0.4'
    xmin: '-0.4'
    ymax: '0.4'
    ymin: '-0.4'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"enco_deco"'
    plotwaterfall: 'False'
    type: float
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"equalizer"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Time sink"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Amplitude_time
    yunit: '"TIme"'
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.000150'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_0_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_0_0_0_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_0_0_0_2
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_0_0_0_3
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input_id
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input_id
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_sub_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', blocks_sub_xx_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', single_pole_iir_filter_xx_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_sub_xx_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', single_pole_iir_filter_xx_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0, '0', blocks_sub_xx_0_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0, '0', single_pole_iir_filter_xx_0_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_0, '0', blocks_sub_xx_0_0_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_0, '0', single_pole_iir_filter_xx_0_0_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_1, '0', blocks_sub_xx_0_0_0_0_0_1, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_1, '0', single_pole_iir_filter_xx_0_0_0_0_0_1, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_2, '0', blocks_sub_xx_0_0_0_0_0_2, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_2, '0', single_pole_iir_filter_xx_0_0_0_0_0_2, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_3, '0', blocks_sub_xx_0_0_0_0_0_3, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_3, '0', single_pole_iir_filter_xx_0_0_0_0_0_3, '0']
- [analog_quadrature_demod_cf_0_0_1, '0', blocks_float_to_char_0, '0']
- [analog_simple_squelch_cc_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', fec_extended_decoder_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0_0_1, '1']
- [blocks_char_to_float_0_0, '0', single_pole_iir_filter_xx_0_0_1, '0']
- [blocks_complex_to_interleaved_char_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_float_to_char_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_1_1_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_sub_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_sub_xx_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [blocks_sub_xx_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0, '0']
- [blocks_sub_xx_0_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0_0, '0']
- [blocks_sub_xx_0_0_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0_0_0, '0']
- [blocks_sub_xx_0_0_0_0_0_1, '0', digital_clock_recovery_mm_xx_0_0_0_0_0_1, '0']
- [blocks_sub_xx_0_0_0_0_0_2, '0', digital_clock_recovery_mm_xx_0_0_0_0_0_2, '0']
- [blocks_sub_xx_0_0_0_0_0_3, '0', digital_clock_recovery_mm_xx_0_0_0_0_0_3, '0']
- [blocks_sub_xx_0_0_1, '0', digital_clock_recovery_mm_xx_0_0_1, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1_0_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1_0_0_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1_0_0_0_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1_0_0_0_1, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1_0_0_0_2, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1_0_0_0_3, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', ieee802_15_4_packet_sink_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', ieee802_15_4_packet_sink_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', ieee802_15_4_packet_sink_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0_0, '0', ieee802_15_4_packet_sink_0_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0_0_0, '0', ieee802_15_4_packet_sink_0_0_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0_0_1, '0', ieee802_15_4_packet_sink_0_0_0_0_0_1, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0_0_2, '0', ieee802_15_4_packet_sink_0_0_0_0_0_2, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0_0_3, '0', ieee802_15_4_packet_sink_0_0_0_0_0_3, '0']
- [digital_clock_recovery_mm_xx_0_0_1, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_linear_equalizer_0, '0', analog_quadrature_demod_cf_0_0_1, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_1_1_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_sink_x_0_1, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', ieee802_15_4_packet_sink_0_0_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_sink_x_0_2, '0']
- [digital_symbol_sync_xx_0_0, '0', blocks_float_to_complex_0, '0']
- [digital_symbol_sync_xx_0_0, '0', ieee802_15_4_packet_sink_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_sink_x_0_0, '0']
- [fec_ber_bf_0, '0', ber_test, '0']
- [fec_ber_bf_0, '0', qtgui_time_sink_x_0, '0']
- [fec_extended_decoder_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_extended_encoder_0, '0', digital_map_bb_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0_1_0, '0']
- [foo_wireshark_connector_0_0, '0', blocks_file_sink_0_0_1_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [ieee802_15_4_packet_sink_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0_0_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0_0_0_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0_0_0_0_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0_0_0_0_1, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0_0_0_0_2, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0_0_0_0_3, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0_1, out, foo_wireshark_connector_0_0, in]
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', digital_linear_equalizer_0, '0']
- [low_pass_filter_0, '0', qtgui_const_sink_x_1_1, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0_1, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_0_1_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [low_pass_filter_0_1_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [low_pass_filter_0_1_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0_0, '0']
- [low_pass_filter_0_1_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0_0_0, '0']
- [low_pass_filter_0_1_0_0_0_1, '0', analog_quadrature_demod_cf_0_0_0_0_0_1, '0']
- [low_pass_filter_0_1_0_0_0_2, '0', analog_quadrature_demod_cf_0_0_0_0_0_2, '0']
- [low_pass_filter_0_1_0_0_0_3, '0', analog_quadrature_demod_cf_0_0_0_0_0_3, '0']
- [osmosdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_1, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [single_pole_iir_filter_xx_0_0, '0', blocks_sub_xx_0_0, '1']
- [single_pole_iir_filter_xx_0_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [single_pole_iir_filter_xx_0_0_0_0, '0', blocks_sub_xx_0_0_0_0, '1']
- [single_pole_iir_filter_xx_0_0_0_0_0, '0', blocks_sub_xx_0_0_0_0_0, '1']
- [single_pole_iir_filter_xx_0_0_0_0_0_0, '0', blocks_sub_xx_0_0_0_0_0_0, '1']
- [single_pole_iir_filter_xx_0_0_0_0_0_1, '0', blocks_sub_xx_0_0_0_0_0_1, '1']
- [single_pole_iir_filter_xx_0_0_0_0_0_2, '0', blocks_sub_xx_0_0_0_0_0_2, '1']
- [single_pole_iir_filter_xx_0_0_0_0_0_3, '0', blocks_sub_xx_0_0_0_0_0_3, '1']
- [single_pole_iir_filter_xx_0_0_1, '0', blocks_sub_xx_0_0_1, '0']
- [virtual_source_0, '0', fec_ber_bf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
