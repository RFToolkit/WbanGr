options:
  parameters:
    generate_options: qt_gui
    id: channelizer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 98,0,1,1
    label: BB
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1,1,1
    type: int
    value: '2438500000'
  states: {}
- name: fun_probe_1
  id: variable_function_probe
  parameters:
    block_id: probe_sig_vector
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    start: '0'
    step: '1'
    stop: '100'
    value: '5'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 97,0,1,1
    label: if_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 96,0,1,1
    start: '0'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: thr
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    start: '-100'
    step: '1'
    stop: '0'
    value: '-70'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: thr
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /opt/gr-wban/wpan.wav
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/gr-wban/wpan.wav
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: round(samp_rate//fft_length//1000)+1
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-100'
    n: '10'
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_length)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf
    bb_gain0: bb_gain
    freq0: freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: vec_length
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_vector_1, '0', qtgui_vector_sink_f_0, '1']
- [blocks_throttle_0, '0', blocks_stream_to_vector_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
